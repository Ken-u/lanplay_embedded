## Config.in
```kconfig
config BR2_PACKAGE_LANPLAY_SERVER_MGR
	bool "lanplay-server-mgr"
	help
	  Provides simple switch lan play server manager
```
